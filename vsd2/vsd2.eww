<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lib_rom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\vsd2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\vsd2_sram.ewp</path>
  </project>
  <batchBuild/>
</workspace>


