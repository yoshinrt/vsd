# IAR project vsd2.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10x ST STM32F10x
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: include; library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: vsd2.s19
  ILINK.IlinkOutputFile: vsd2.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration exec_sram (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; EXEC_SRAM
  postbuild: s2bin\s2bin exec_sram\Exe\vsd2.s19
  ILINK.IlinkIcfFile: STM32F10x_SRAM.icf
  group Application Files
    ./: cortexm3_macro.s diskio.c ff.c hw_config.c main.c msd.c stm32f10x_it.c stm32f10x_vector.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group FWLib
    library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
