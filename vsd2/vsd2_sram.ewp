# IAR project vsd2_sram.ewp, settings and files
configuration exec_sram (ARM)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: VECT_TAB_FLASH; EXEC_SRAM
  ICCARM.CCIncludePath2: include; library\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vsd2.s19
  postbuild: Z:\bin\s2bin.exe z:\exec_sram\Exe\vsd2.s19
  ILINK.IlinkOutputFile: vsd2.out
  ILINK.IlinkIcfFile: Z:\STM32F10x_SRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application Files
    src/: main.c rom_entry.s stm32f10x_it.c stm32f10x_vector.c usart.c
  group FWLib
    library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
